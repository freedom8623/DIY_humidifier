# Keil uVision project IR_Remote_Rx.uvproj, settings and files
target IR_Remote_Rx (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: IR_Remote_Rx +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: IR_Remote_Rx.asm 功能说明.txt
